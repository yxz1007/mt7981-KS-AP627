## package/mtk/applications/wappd/Config.in
```kconfig
config WAPP_WPACTRL_SUPPORT
        bool "Support WPACTRL in wapp"
        default n
        depends on PACKAGE_wapp
```
